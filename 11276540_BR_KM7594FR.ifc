Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-02-09T07:12:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 09 07:12:50 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{CE65D223-580F-42EB-A48B-6BFC87E9A1B2}\ifc * Database version: 5507 * Database creation date: Tue Feb 09 07:12:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 09 07:12:49 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 09 07:12:49 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26759400_BR_11276540_KM7594FR, 11276540_BR_KM7594FR:26759400_BR_11276540_KM7594FR:204695
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Stainless Steel, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - Reference: 26759400_BR_11276540_KM7594FR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
